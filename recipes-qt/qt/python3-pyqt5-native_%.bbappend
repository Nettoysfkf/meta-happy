PYQT_MODULES:remove = "QtGui"
