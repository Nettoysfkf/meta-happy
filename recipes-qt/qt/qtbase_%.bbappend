PACKAGECONFIG:append = " gl gles2 gbm eglfs tools kms xcb fontconfig icu"
