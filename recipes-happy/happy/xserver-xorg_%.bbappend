DEPENDS:append = "libxinerama"
XSERVER_RDEPENDS:append = "libxinerama"
PACKAGECONFIG:append = "xinerama"
