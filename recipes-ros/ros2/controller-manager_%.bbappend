FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-controller-manager-temp-fix-warning-as-error.patch"
