FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-SuiteSparse-was-confirm-to-build-with-ceres.patch"
