FILES:${PN}-dev += "/opt/ros/humble/lib/libmoveit*.so"
