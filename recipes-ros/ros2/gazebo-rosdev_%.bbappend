DEPENDS:append = " pkgconfig-native"
