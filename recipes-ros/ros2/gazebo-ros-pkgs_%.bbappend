LICENSE = "BSD-3-Clause"
inherit cmake_qt5
