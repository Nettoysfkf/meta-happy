DEPENDS:append = " pkgconfig-native gazebo11"
