FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-controller-interface-tmp-fix-warning-as-error.patch"
