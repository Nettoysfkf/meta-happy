EXTRA_OECMAKE += " \
    -DCMAKE_CXX_FLAGS='-Wno-error=deprecated-declarations' \
"
