FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-hardware-interface-temp-fix-warning-as-error.patch"
