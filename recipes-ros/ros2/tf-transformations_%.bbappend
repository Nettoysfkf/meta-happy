ROS_BUILD_DEPENDS:append = " python3-transforms3d"
ROS_EXPORT_DEPENDS:append = " python3-transforms3d"
ROS_EXEC_DEPENDS:append = " python3-transforms3d"
