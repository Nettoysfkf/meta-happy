FILES:${PN}-dev += "/opt/ros/humble/lib/*"
