EXTRA_OECMAKE += " \
    -DCMAKE_CXX_FLAGS='-Wno-error=deprecated-declarations -Wno-error=pedantic -Wno-error=unused-parameter' \
"
