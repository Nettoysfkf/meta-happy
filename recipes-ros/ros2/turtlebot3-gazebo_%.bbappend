DEPENDS:append = " gazebo11 pkgconfig-native"
