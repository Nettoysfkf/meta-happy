DEPENDS:append = " libxinerama libxkbcommon libxkbfile glm shaderc glslang"
