FILES:${PN}-dev += "/opt/ros/humble/lib/libmoveit_chomp_interface.so"
