ALLOW_EMPTY:${PN} = "1"
PACKAGECONFIG = "suitesparse lapack"
