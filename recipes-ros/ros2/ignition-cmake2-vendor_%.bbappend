DEPENDS:append = " ignition-cmake2"
