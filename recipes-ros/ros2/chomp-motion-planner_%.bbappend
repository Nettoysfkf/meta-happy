FILES:${PN}-dev += " /opt/ros/humble/lib/libchomp_motion_planner.so"

