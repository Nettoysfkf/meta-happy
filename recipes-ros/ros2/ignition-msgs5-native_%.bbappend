EXTRA_OECMAKE += "-DINSTALL_IGN_MSGS_GEN_EXECUTABLE:BOOL=ON -DCMAKE_CXX_STANDARD=17"
