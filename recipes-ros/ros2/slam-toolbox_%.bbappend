FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-slam-toolbox-ceres-already-build-with-suitesparse.patch"
